## dts/bindings/behaviors/zmk,behavior-touchpass.yaml
```yaml
description: TouchPass Fingerprint Behavior

compatible: "zmk,behavior-touchpass"

include: zero_param.yaml
```
